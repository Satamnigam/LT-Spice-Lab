*
.include 180nm_model.txt
.include inv.txt
vdd 1 0 dc 1.8
vss 0 0 dc 0
vd 2 0 pulse(0 1.8 1n 0.1n 0.1n 20n 40n )
vclk 3 0 pulse(0 1.8 2n 0.1n 0.1n 10n 20n)
Xinv1 3 4 inv
Xinv2 2 5 inv

MN1 5 4 6 0 N_180 w=5u l=.18u
MP1 5 3 6 1 P_180 w=5u l=.18u
Xinv3 6 7 inv

MN2 7 3 8 0 N_180 w=5u l=.18u
MP2 7 4 8 1 P_180 w=5u l=.18u
Xinv4 8 9 inv
Xinv5 9 10 inv

.trans 0 100n
*.print v(2) v(3) v(10)
