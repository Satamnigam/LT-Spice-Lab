*
.include 180nm_model.txt
.include inv.txt
.include tg.txt

va A 0 pulse(0 1.8 1n 0.1n 0.1n 20n 40n)
vb B 0 pulse(0 1.8 5n 0.1n 0.1n 10n 20n)

v1 i0 0 pulse(0 1.8 7n 0.1n 0.1n 5n 40n)
v2 i1 0 pulse(0 1.8 1n 0.1n 0.1n 5n 20n)
v3 i2 0 pulse(0 1.8 13n 0.1n 0.1n 5n 40n)
v4 i3 0 pulse(0 1.8 25n 0.1n 0.1n 5n 20n)
Xinv1 A Abar inv
Xinv2 B Bbar inv

Xtg1 i0 Bbar o1 tg
Xtg2 i1 B o1 tg
Xtg3 i2 Bbar o2 tg
Xtg4 i3 B o2 tg

Xtg5 o1 Abar out tg
Xtg6 o2 A out tg

.trans 0 100n
